# IAR project modbsu.ewp, settings and files
configuration modbsu (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; STM32_THREAD_SAFE_STRATEGY=4
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\Drivers\CMSIS\Include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\Middlewares\FreeModbus\include; ..\Middlewares\FreeModbus\rtu; ..\Middlewares\FreeModbus\Port
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: modbsu.hex
  ILINK.IlinkOutputFile: modbsu.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: dlib_lock_glue.c startup_stm32f103xb.s dlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/Modbus
    ../Middlewares/FreeModbus/: mb.c
  group Middlewares/Modbus/Func
    ../Middlewares/FreeModbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../Middlewares/FreeModbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/Modbus/Port
    ../Middlewares/FreeModbus/Port/: port.h port_other.c portevent.c portserial.c porttcp.c porttimer.c user_mb_app.c user_mb_app.h
